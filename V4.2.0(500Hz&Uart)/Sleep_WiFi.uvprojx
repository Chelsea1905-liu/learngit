# Keil uVision project Sleep_WiFi.uvprojx, settings and files
target WIFI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Sleep_WiFI_V4.0.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64  S132 NRF_LOG_USES_UART=1 NRF52  SOFTDEVICE_PRESENT  CONFIG_NFCT_PINS_AS_GPIOS SWI_DISABLE0
  c include: .\APP;.\BLE\ble_advertising;.\BLE\ble_services\ble_dis;.\BLE\ble_services\ble_nus;.\BLE\common;.\Doc;.\Drivers\bsp;.\Drivers\common;.\Drivers\config;.\Drivers\delay;.\Drivers\flash;.\Drivers\hal;.\Drivers\ppi;.\Drivers\pstorage\config;.\Drivers\pstorage;.\Drivers\RTE;.\Drivers\saadc;.\Drivers\segger_rtt;.\Drivers\timer;.\Drivers\uart;.\Libraries\fifo;.\Libraries\fstorage;.\Libraries\gpiote;.\Libraries\pwm;.\Libraries\timer;.\Libraries\uart;.\Libraries\util;.\RTE\Device\nRF52832_xxAA;.\softdevice\common\softdevice_handler;.\softdevice\s132\headers;.\Libraries\experimental_section_vars;.\Libraries\fstorage\config;.\Drivers\bsp;.\Drivers\Bluetooth;.\Drivers\simuart;.\Drivers\wifi;.\Drivers\wdt;.\RSA
  asm define: BSP_DEFINES_ONLY BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64  NRF52
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
  group APP
    ./APP/: app_gpio_in_out.c main.c Parameter.c Fun.c app_it.c MD5.c ring_buffer.c
    ./Drivers/bsp/: bsp_btn_ble.c bsp.c
    ./Drivers/flash/: FLASH.c
    ./Drivers/Bluetooth/: BLE_NRF.c
    ./Drivers/wdt/: nrf_drv_wdt.c
    ./RSA/: sleep_1_5.lib
  group Drivers
    ./Drivers/delay/: nrf_delay.c
    ./Drivers/uart/: nrf_drv_uart.c
    ./Drivers/common/: nrf_drv_common.c
    ./Libraries/gpiote/: nrf_drv_gpiote.c
    ./Drivers/timer/: nrf_drv_timer.c
    ./Drivers/ppi/: nrf_drv_ppi.c
    ./Libraries/uart/: app_uart_fifo.c
    ./Drivers/saadc/: nrf_drv_saadc.c
    ./Drivers/hal/: nrf_saadc.c
    ./Drivers/pstorage/: pstorage.c
    ./APP/: nrf_drv_clock.c
  group Libraries
    ./Libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ./Libraries/uart/: retarget.c
    ./Libraries/fstorage/: fstorage.c
    ./Libraries/fifo/: app_fifo.c
    ./Libraries/pwm/: app_pwm.c
    ./Libraries/timer/: app_timer.c
  group Doc
    ./Doc/: readme.txt
  group SoftDevice
    ./softdevice/common/softdevice_handler/: softdevice_handler.c
  group BLE
    ./BLE/ble_advertising/: ble_advertising.c
    ./BLE/ble_services/ble_dis/: ble_dis.c
    ./BLE/ble_services/ble_nus/: ble_nus.c
    ./BLE/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group Segger_RTT
    ./Drivers/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c RTT_Syscalls_KEIL.c
target Flash_SoftDevices (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: s132_nrf52_2.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
software components: CMSIS:CORE 5.3.0, Device:Startup 8.5.0
